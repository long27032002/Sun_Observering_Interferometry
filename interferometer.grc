options:
  parameters:
    author: Nguyen Nhu Hai Long
    copyright: '@Nguyen Nhu Hai Long'
    generate_options: no_gui
    id: Interferometer
    output_language: python
    run_options: run
    title: Interferometer
  states: {}

blocks:
- name: Datetime
  id: variable
  parameters:
    value: datetime.now().strftime("%Y_%m_%d")
  states: {}
- name: Frequency
  id: variable
  parameters:
    value: '610000000'
  states: {}
- name: Sample
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: Vector_length
  id: variable
  parameters:
    value: '512'
  states: {}
- name: path
  id: variable
  parameters:
    value: '"/home"'
  states: {}
- name: timenow
  id: variable
  parameters:
    value: datetime.now().strftime("%Y_%m_%d_%H_%M_%S")
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: Vector_length
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '500'
    scale: 1/100
    type: float
    vlen: Vector_length
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: Vector_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Vector_length
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class integration(gr.decim_block):
          """
          docstring for block integration
          """
          def __init__(self, vec_length=512, n_integrations=1):
              gr.decim_block.__init__(self,
                  name="integration",
                  in_sig=[(np.float32, int(vec_length))],
                  out_sig=[(np.float32, int(vec_length))], 
                  decim = n_integrations)
              self.n_integrations = n_integrations
              self.vec_length = vec_length
              self.set_relative_rate(1.0/n_integrations)
              self.sum = np.zeros(self.vec_length)
              self.integration_count = 0


          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              for inp0 in in0:
                  if self.integration_count < self.n_integrations:
                      self.sum = self.sum + inp0
                      self.integration_count += 1
                  else:
                      out[:] = self.sum[:]/self.n_integrations
                      self.sum = np.zeros(self.vec_length)
                      self.integration_count = 0
              return len(output_items[0])

          def set_n_integrations(self, n_integrations):
              self.n_integrations = n_integrations
              self.set_relative_rate(1.0/n_integrations)
              print("Rate Updated")
    n_integrations: int(Frequency/Sample)
    vec_length: Vector_length
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """


      import numpy as np
      from gnuradio import gr

      class integration(gr.decim_block):
          """
          docstring for block integration
          """
          def __init__(self, vec_length=512, n_integrations=1):
              gr.decim_block.__init__(self,
                  name="integration",
                  in_sig=[(np.float32, int(vec_length))],
                  out_sig=[(np.float32, int(vec_length))], 
                  decim = n_integrations)
              self.n_integrations = n_integrations
              self.vec_length = vec_length
              self.set_relative_rate(1.0/n_integrations)
              self.sum = np.zeros(self.vec_length)
              self.integration_count = 0


          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              for inp0 in in0:
                  if self.integration_count < self.n_integrations:
                      self.sum = self.sum + inp0
                      self.integration_count += 1
                  else:
                      out[:] = self.sum[:]/self.n_integrations
                      self.sum = np.zeros(self.vec_length)
                      self.integration_count = 0
              return len(output_items[0])

          def set_n_integrations(self, n_integrations):
              self.n_integrations = n_integrations
              self.set_relative_rate(1.0/n_integrations)
              print("Rate Updated")
    n_integrations: '21'
    vec_length: Vector_length
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      from datetime import datetime

      class csv_filesink(gr.sync_block):
          """
          This block is controlled by the string variable save_toggle: if save_toggle = "True" (a string, not boolean), the data is written to a new .csv file every new integration time. The minimum integration time for the block to work is 0.1 s. 
          """
          def __init__(self, vec_length=512, samp_rate=2400000, freq=610000000, prefix="", save_toggle="True", integration_select=0, short_long_time_scale=1, az="", elev="", location=""):
              gr.sync_block.__init__(self,
                  name="csv_filesink",
                  in_sig=[(np.float32, int(vec_length))],
                  out_sig=None)

              self.vec_length = int(vec_length)
              self.samp_rate = samp_rate
              self.freq = freq
              self.prefix = prefix
              self.save_toggle = save_toggle
              self.integration_select = integration_select
              self.short_long_time_scale = short_long_time_scale
              self.az = az
              self.elev = elev
              self.location = location

              self.frequencies = np.arange(freq - samp_rate/2, freq + samp_rate/2, samp_rate/vec_length)[:vec_length]
              self.data_array = np.zeros((vec_length,2))
              self.N_long_counter = 0
              self.spectrum = np.zeros(vec_length)

          def work(self, input_items, output_items):
              # in0 = input_items[0]
              # self.spectrum[:] = in0

              in0_buffer = input_items[0]

              for in0 in in0_buffer:

              # <+signal processing here+>

                  if self.save_toggle == "True":     #If true, capture the spectrum to a new .csv text file each integration.
                      if self.integration_select == 0:
                          current_time = time.time()
                          self.timenow = datetime.now().strftime("%Y_%m_%d_%H_%M_%S_%f")[:-5]
                          #write (freq, output) as a column array to a text file, titled e.g. "2018-07-24_15.15.49_spectrum.txt"
                          # The "prefix", i.e. the file path, is defined in the prefix variable box in the .grc program.
                          self.textfilename = self.prefix + self.timenow + "_PSD.csv"
                          self.data_array[:,0] = np.round(self.frequencies/1e6, decimals=4)
                          self.data_array[:,1] = np.round(in0, decimals=4)
                          np.savetxt(self.textfilename, self.data_array, delimiter=',')

                          self.N_long_counter = self.N_long_counter + 1  #Increase counter for long integration print to .csv

                      else:
                          if self.N_long_counter >= self.short_long_time_scale-1:
                              current_time = time.time()
                              self.timenow = datetime.now().strftime("%Y-%m-%d_%H.%M.%S.%f")[:-5]
                              #write (freq, output) as a column array to a text file, titled e.g. "2018-07-24_15.15.49_spectrum.txt"
                              # The "prefix", i.e. the file path, is defined in the prefix variable box in the .grc program.
                              self.textfilename = self.prefix + self.timenow + "_PSD.csv"
                              self.data_array[:,0] = np.round(self.frequencies/1e6, decimals=4)
                              self.data_array[:,1] = np.round(in0, decimals=4)
                              np.savetxt(self.textfilename, self.data_array, delimiter=',')
                              #
                              self.N_long_counter = 0
                          else:
                              self.N_long_counter = self.N_long_counter + 1  #Increase counter for long integration print to .csv
                  
                  return len(input_items[0])

          def set_save_toggle(self, save_toggle):
              self.save_toggle = save_toggle

          def set_integration_select(self, integration_select):
              self.integration_select = integration_select

          def set_az(self, az):
              self.az = az

          def set_elev(self, elev):
              self.elev = elev

          def set_location(self, location):
              self.location = location
    az: '""'
    elev: '""'
    freq: Frequency
    integration_select: '0'
    location: '""'
    prefix: f"{path}/{Datetime}/"
    samp_rate: Sample
    save_toggle: '"True"'
    short_long_time_scale: '0'
    vec_length: Vector_length
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '0'
    freq0: Frequency
    gain0: '40'
    gain_mode0: 'True'
    if_gain0: '0'
    sample_rate: Sample
    sync: sync
    type: fc32
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.1'
    grid: 'True'
    name: '"PSD"'
    update_time: '2'
    vlen: Vector_length
    x_axis_label: '"Frequency"'
    x_start: Frequency-Sample/2
    x_step: int(Sample/Vector_length)
    x_units: '"MHz"'
    y_axis_label: '"Power"'
    y_units: '"dB"'
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_complex_to_mag_squared_0, '0']
- [epy_block_0, '0', epy_block_0_0, '0']
- [epy_block_0, '0', qtgui_vector_sink_f_0, '0']
- [epy_block_0_0, '0', epy_block_1_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
